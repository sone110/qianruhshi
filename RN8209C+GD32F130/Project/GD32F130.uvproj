# Keil uVision project GD32F130.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: GD32F130G6 GigaDevice
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x08000000-0x08007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GD32F130 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\Application;..\CMSIS\GD\GD32F1x0\Include;..\CMSIS;..\Peripheral\Include;..\Utilities;..\Project;..\USER\BQ27541;..\USER\IIC;..\USER\RS485;..\USER\usart;..\USER\RN8209D;..\MODBUS\include;..\MODBUS\rtu;..\MODBUS\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ../CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
    ../CMSIS/: core_cm3.h
  group Application
    ../Application/: gd32f1x0_it.c main.c systick.c
  group Peripherals
    ../Peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Utilities
    ../Utilities/: gd32f1x0_eval.c
  group User
    ../USER/usart/: usart.c
    ../USER/RS485/: RS485.c
    ../USER/RN8209D/: RN8209D.c
  group FreeModbus
    ../MODBUS/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../MODBUS/rtu/: mbcrc.c mbrtu.c
    ../MODBUS/: mb.c
  group Port
    ../MODBUS/port/: portevent.c portserial.c porttimer.c
